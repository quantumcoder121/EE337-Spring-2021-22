ORG 0H
LJMP MAIN
ORG 100H
MAIN:
MOV A, 30H
MOV B, A
MUL AB
MOV R0, A
MOV A, R0
MOV R7, A
LOOP:
MOV A, R0
CLR C
ADD A, #30H
MOV R1, A
MOV A, @R1
MOV R2, A
MOV A, R0
CLR C
ADD A, #30H
CLR C
ADD A, R7
MOV R1, A
MOV A, @R1
MOV R3, A
MOV A, R2
CLR C
ADD A, R3
MOV R4, A
MOV A, R0
CLR C
ADD A, #30H
CLR C
ADD A, R7
CLR C
ADD A, R7
MOV R1, A
MOV A, R4
MOV @R1, A
DJNZ R0, LOOP
RET
END