ORG 0H
MOV A, 30H
MOV B, #10H
DIV AB
MOV R0, A
MOV R1, B
MOV A, #09H
SUBB A, R0
JNC NCARRY1
MOV A, R0
ADD A, #37H
MOV 60H, A
LJMP CARRY1
NCARRY1:
MOV A, R0
ADD A, #30H
MOV 60H, A
CARRY1:
MOV A, #09H
SUBB A, R1
JNC NCARRY2
MOV A, R1
ADD A, #37H
MOV 61H, A
LJMP CARRY2
NCARRY2:
MOV A, R1
ADD A, #30H
MOV 61H, A
CARRY2:
END